# Keil uVision project blinky.uvproj, settings and files
target Bootload (MCS-51)
  device: EFM8UB20F64G-QFP48 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: blinky +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\inc;C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base
  group src
    ../../../../src/: gpio.c init.c main.c
  group A51
    ./: STARTUP_BOOTLOAD.A51
